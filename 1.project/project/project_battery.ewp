# IAR project project_battery.ewp, settings and files
configuration Debug (STM8, debug)
  General.GenDeviceSelectMenu: STM8S105C6 STM8S105C6
  General.GenCodeModel: 0
  General.GenDataModel: 1
  General.GenStackSize: 0x100
  General.GenHeapSize: 0x100
  ICCSTM8.CCDefines: STM8S105
  ICCSTM8.CCIncludePath2: C:\Users\Thai MCU\Documents\3.STM8s\1.project\project; C:\Users\Thai MCU\Documents\3.STM8s\1.project\library; C:\Users\Thai MCU\Documents\3.STM8s\1.project\user
  ICCSTM8.IccLang: 0
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkStackSize: 1
  ILINK.IlinkHeapSize: 1
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (STM8)
  as the first configuration, except:
  ICCSTM8.CCDefines: NDEBUG
  group Lib_dirver
    ../user/: delay.c KALMAN.c timer.c uart.c uart_frame.c
  group Lib_sensor
    ../user/: mcp3208.c sensor_gpio.c sys.c
  group Lib_start
    ../library/: stm8s_gpio.c stm8s_it.c stm8s_spi.c stm8s_tim4.c
  group User
    ./: main.c
