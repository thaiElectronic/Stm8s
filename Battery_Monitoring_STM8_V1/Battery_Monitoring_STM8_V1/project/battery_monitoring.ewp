# IAR project battery_monitoring.ewp, settings and files
configuration Debug (STM8, debug)
  General.GenDeviceSelectMenu: STM8S105C6 STM8S105C6
  General.GenCodeModel: 0
  General.GenDataModel: 1
  General.GenStackSize: 0x100
  General.GenHeapSize: 0x100
  ICCSTM8.CCIncludePath2: ..\library; ..\user
  ICCSTM8.IccLang: 0
  OBJCOPY.OOCOutputFile: battery_monitoring.srec
  ILINK.IlinkOutputFile: battery_monitoring.out
  ILINK.IlinkStackSize: 1
  ILINK.IlinkHeapSize: 1
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (STM8)
  as the first configuration, except:
  ICCSTM8.CCDefines: NDEBUG
  group library_driver
    ../user/: delay.c timer.c uart.c
  group library_h
    ../user/: delay.h mcp3208.h sensor_gpio.h sys.h sys_define.h timer.h uart.h
  group library_sensor
    ../user/: mcp3208.c sensor_gpio.c sys.c
  group library_start
    ../library/: STM8CONFIG.h stm8s.h stm8s_conf.h stm8s_gpio.c stm8s_gpio.h stm8s_it.c stm8s_it.h stm8ss.h
    ../user/: stm8s_clk.c stm8s_i2c.c stm8s_spi.c stm8s_spi.h
  group OLED_IIC
    ../user/: fonts.h SSD1306.c SSD1306.h
  group User
    ../user/: main.c
