# IAR project TIMDELAY.ewp, settings and files
configuration Debug (STM8, debug)
  General.GenDeviceSelectMenu: STM8S105C6 STM8S105C6
  General.GenCodeModel: 0
  General.GenDataModel: 1
  General.GenStackSize: 0x100
  General.GenHeapSize: 0x100
  ICCSTM8.CCDefines: STM8S105
  ICCSTM8.CCIncludePath2: C:\Users\Thai MCU\Documents\3.STM8s\7.1TIM4_Delay\Project; C:\Users\Thai MCU\Documents\3.STM8s\7.1TIM4_Delay; C:\Users\Thai MCU\Documents\3.STM8s\7.1TIM4_Delay\Lib\inc; C:\Users\Thai MCU\Documents\3.STM8s\7.1TIM4_Delay\Lib\src
  ICCSTM8.IccLang: 0
  OBJCOPY.OOCOutputFile: TIMDELAY.srec
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkStackSize: 1
  ILINK.IlinkHeapSize: 1
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (STM8)
  as the first configuration, except:
  ICCSTM8.CCDefines: NDEBUG
  group Lib_ST
    ./: STM8CONFIG.h stm8s.h stm8s_conf.h stm8s_it.c stm8s_it.h
    ../Lib/src/: stm8s_clk.c stm8s_gpio.c stm8s_tim2.c
    ../../10.Timer_counter/User/: uart.c
  group User
    ./: main.c
