# IAR project gpio_basic.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: S3C4530A Samsung S3C4530A
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: STM8S103
  ICCARM.CCIncludePath2: C:\Users\Thai MCU\Documents\3.STM8s\GPIO_Basic\project\Debug; C:\Users\Thai MCU\Documents\3.STM8s\GPIO_Basic\Lib; C:\Users\Thai MCU\Documents\3.STM8s\GPIO_Basic\user
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: gpio_basic.srec
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group lib
    ../user/: DELAY.c gpio.c sys.c tiny-json.c uart.c
  group user
    ../user/: main.c
    ../Lib/: STM8CONFIG.h stm8s_gpio.c stm8s_it.c
