# IAR project counter.ewp, settings and files
configuration Debug (STM8, debug)
  General.GenDeviceSelectMenu: STM8S105C6 STM8S105C6
  General.GenCodeModel: 0
  General.GenDataModel: 1
  General.GenStackSize: 0x100
  General.GenHeapSize: 0x100
  ICCSTM8.CCDefines: STM8S105
  ICCSTM8.CCIncludePath2: C:\Users\Thai MCU\Documents\3.STM8s\10.Timer_counter\User; C:\Users\Thai MCU\Documents\3.STM8s\10.Timer_counter\Library\inc; C:\Users\Thai MCU\Documents\3.STM8s\10.Timer_counter\Library\src
  ICCSTM8.IccLang: 0
  OBJCOPY.OOCOutputFile: counter.srec
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkStackSize: 1
  ILINK.IlinkHeapSize: 1
configuration Release (STM8)
  as the first configuration, except:
  ICCSTM8.CCDefines: NDEBUG
  group Lib_Driver
    ../Library/src/: stm8s_clk.c stm8s_gpio.c stm8s_tim2.c
    ./: uart.c
  group Lib_Start
    ./: STM8CONFIG.h stm8s.h stm8s_conf.h stm8s_it.c stm8s_it.h
  group User
    ./: main.c
