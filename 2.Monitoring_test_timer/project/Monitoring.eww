<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\..\..\2.Monitoring_test_timer\project\Monitoring.ewp</path>
    </project>
    <batchBuild />
</workspace>
