# IAR project Monitoring.ewp, settings and files
configuration Debug (STM8, debug)
  General.GenDeviceSelectMenu: STM8S105C6 STM8S105C6
  General.GenCodeModel: 0
  General.GenDataModel: 1
  General.GenStackSize: 0x100
  General.GenHeapSize: 0x100
  ICCSTM8.CCDefines: STM8S105
  ICCSTM8.CCIncludePath2: C:\Users\Thai MCU\Desktop\Monitor system\1.DEV_Code\Battery_Monitoring_STM8_V1\2.Monitoring_test_timer\project; C:\Users\Thai MCU\Desktop\Monitor system\1.DEV_Code\Battery_Monitoring_STM8_V1\2.Monitoring_test_timer\library; C:\Users\Thai MCU\Desktop\Monitor system\1.DEV_Code\Battery_Monitoring_STM8_V1\2.Monitoring_test_timer\user
  ICCSTM8.IccLang: 0
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkStackSize: 1
  ILINK.IlinkHeapSize: 1
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (STM8)
  as the first configuration, except:
  ICCSTM8.CCDefines: NDEBUG
  group Lib_driver
    ../user/: delay.c timer.c uart.c
  group Lib_sensor
    ../user/: mcp3208.c sensor_gpio.c sys.c
  group Lib_start
    ../library/: STM8CONFIG.h stm8s.h stm8s_conf.h stm8s_gpio.c stm8s_gpio.h stm8s_it.c stm8s_it.h stm8ss.h
    ../user/: stm8s_spi.c stm8s_spi.h
  group User
    ./: main.c
