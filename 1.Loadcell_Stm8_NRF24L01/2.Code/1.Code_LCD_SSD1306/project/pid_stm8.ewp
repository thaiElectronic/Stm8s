# IAR project pid_stm8.ewp, settings and files
configuration Debug (STM8, debug)
  General.GenDeviceSelectMenu: STM8S103F3P STM8S103F3P
  General.GenCodeModel: 0
  General.GenDataModel: 1
  General.GenStackSize: 0x100
  General.GenHeapSize: 0x100
  ICCSTM8.CCIncludePath2: ..\user; ..\library
  ICCSTM8.IccLang: 0
  OBJCOPY.OOCOutputFile: pid_stm8.srec
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkStackSize: 1
  ILINK.IlinkHeapSize: 1
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (STM8)
  as the first configuration, except:
  ICCSTM8.CCDefines: NDEBUG
  group driver
    ../user/: DELAY.c i2c.c ssd1306.c stm8s_gpio.c stm8s_i2c.c uart.c
  group File_H
    ../user/: DELAY.h fonts.h i2c.h ssd1306.h stm8s_gpio.h stm8s_i2c.h uart.h
  group lib
    ../library/: stm8s.h stm8s_conf.h stm8s_it.c stm8s_it.h
  group user
    ../user/: main.c
