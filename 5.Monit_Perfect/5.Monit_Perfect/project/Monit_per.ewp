# IAR project Monit_per.ewp, settings and files
configuration Debug (STM8, debug)
  General.GenDeviceSelectMenu: STM8S105C6 STM8S105C6
  General.GenCodeModel: 0
  General.GenDataModel: 1
  General.GenStackSize: 0x100
  General.GenHeapSize: 0x100
  ICCSTM8.CCDefines: STM8S105
  ICCSTM8.CCIncludePath2: C:\Users\Thai MCU\Documents\3.STM8s\5.Monit_Perfect\5.Monit_Perfect\library\inc; C:\Users\Thai MCU\Documents\3.STM8s\5.Monit_Perfect\5.Monit_Perfect\library\src; C:\Users\Thai MCU\Documents\3.STM8s\5.Monit_Perfect\5.Monit_Perfect\library; C:\Users\Thai MCU\Documents\3.STM8s\5.Monit_Perfect\5.Monit_Perfect\project; C:\Users\Thai MCU\Documents\3.STM8s\5.Monit_Perfect\5.Monit_Perfect\user
  ICCSTM8.IccLang: 0
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkStackSize: 1
  ILINK.IlinkHeapSize: 1
configuration Release (STM8)
  as the first configuration, except:
  ICCSTM8.CCDefines: NDEBUG
  group Lib_driver
    ../user/: delay.c timer.c uart.c
  group Lib_sensor
    ../user/: KALMAN.c mcp3208.c sensor_gpio.c sys.c
  group Lib_start
    ../user/: json-maker.c stm8s_spi.c tiny-json.c
    ../library/: STM8CONFIG.h stm8s.h stm8s_conf.h stm8s_gpio.c stm8s_gpio.h stm8s_it.c stm8s_it.h stm8ss.h
    ../library/src/: stm8s_clk.c stm8s_tim4.c stm8s_wwdg.c
  group User
    ./: main.c
